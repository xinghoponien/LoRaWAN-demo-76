# Keil uVision project LoRaWAN-demo-76.uvprojx, settings and files
target LoRaWAN-demo-76 (6070000::V6.7::.\ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: CPUTYPE("Cortex-M0+")
  output: LoRaWAN-demo-76
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: TARGET_FF_ARDUINO MBED_MINIMAL_PRINTF DEVICE_PWMOUT=1 DEVICE_SPI_ASYNCH=1 MBED_TICKLESS DEVICE_MPU=1 TARGET_STM32L073RZ MBED_RAM_START=0x20000000 TARGET_FF_MORPHO DEVICE_I2CSLAVE=1 DEVICE_STDIO_MESSAGES=1 DEVICE_RTC=1 TOOLCHAIN_ARM USE_FULL_LL_DRIVER TOOLCHAIN_ARM_STD DEVICE_LPTICKER=1 TARGET_CORTEX_M MBED_RTOS_SINGLE_THREAD DEVICE_ANALOGOUT=1 DEVICE_SPISLAVE=1 DEVICE_SPI=1 __CORTEX_M0PLUS TARGET_STM32L0 ARM_MATH_CM0PLUS DEVICE_SERIAL=1 __MICROLIB DEVICE_SLEEP=1 DEVICE_USTICKER=1 DEVICE_WATCHDOG=1 TARGET_MCU_STM32 TARGET_CORTEX DEVICE_TRNG=1 __ASSERT_MSG DEVICE_PORTINOUT=1 DEVICE_I2C_ASYNCH=1 TARGET_LIKE_MBED MBED_ROM_START=0x8000000 TARGET_NUCLEO_L073RZ TOOLCHAIN_ARMC6 TARGET_NAME=NUCLEO_L073RZ DEVICE_FLASH=1 DEVICE_PORTOUT=1 DEVICE_INTERRUPTIN=1 DEVICE_SERIAL_FC=1 DEVICE_CRC=1 __MBED_CMSIS_RTOS_CM MULADDC_CANNOT_USE_R7 USE_HAL_DRIVER DEVICE_RESET_REASON=1 MBED_TRAP_ERRORS_ENABLED=1 MBED_RAM_SIZE=0x5000 EXTRA_IDLE_STACK_REQUIRED __CMSIS_RTOS DEVICE_ANALOGIN=1 TARGET_MCU_STM32_BAREMETAL __MBED__=1 MBED_BUILD_TIMESTAMP=1622183855.43016 MBED_ROM_SIZE=0x30000 TARGET_STM32L073xx DEVICE_SERIAL_ASYNCH=1 TARGET_RELEASE TARGET_LIKE_CORTEX_M0 TARGET_M0P TARGET_STM DEVICE_I2C=1 TRANSACTION_QUEUE_SIZE_SPI=2 DEVICE_PORTIN=1
  c misc: -mthumb -fno-c++-static-destructors -Wno-reserved-user-defined-literal -c -fno-exceptions --target=arm-arm-none-eabi -fshort-enums -fshort-wchar -Wno-deprecated-register -Wno-armcc-pragma-push-pop -mcpu=cortex-m0plus -fno-rtti -Wno-armcc-pragma-anon-unions -fdata-sections -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;app;board;mac;mac/LoRaWAN-lib;mbed;mbed/TARGET_NUCLEO_L073RZ;mbed/TARGET_NUCLEO_L073RZ/TARGET_STM;mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0;mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0/TARGET_NUCLEO_L073RZ;mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0/TARGET_NUCLEO_L073RZ/device;mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0/device;mbed/drivers;mbed/hal;mbed/platform;radio;radio/SX1276Lib;radio/SX1276Lib/debug;radio/SX1276Lib/enums;radio/SX1276Lib/radio;radio/SX1276Lib/registers;radio/SX1276Lib/sx1276;radio/SX1276Lib/typedefs;system;system/crypto
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DUSE_FULL_LL_DRIVER,-DMBED_TICKLESS,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M0PLUS,-D__CMSIS_RTOS,-DEXTRA_IDLE_STACK_REQUIRED,-DUSE_HAL_DRIVER,-DARM_MATH_CM0PLUS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_L073RZ/TOOLCHAIN_ARM_STD/stm32l073xz.sct
  link misc: --cpu=Cortex-M0plus --predefine="-DXIP_ENABLE=0" --keep=os_cb_sections --legacyalign --predefine="-DMBED_RAM_SIZE=0x5000" --predefine="-DMBED_BOOT_STACK_SIZE=1024" --library_type=microlib --predefine="-DMBED_ROM_SIZE=0x30000" --show_full_path --inline --any_contingency --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_ROM_START=0x8000000"
  group app
    app/: Commissioning.h main.cpp SerialDisplay.cpp SerialDisplay.h vt100.h
  group board
    board/: board.cpp board.h
  group LoRaWAN-demo-76
    ./: mbed_config.h
  group mac
    mac/LoRaWAN-lib/: LoRaMac-definitions.h LoRaMac.cpp LoRaMac.h LoRaMacCrypto.cpp LoRaMacCrypto.h LoRaMacTest.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_L073RZ/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32l073xx.o stm32l0xx_hal.o stm32l0xx_hal_adc.o stm32l0xx_hal_adc_ex.o stm32l0xx_hal_comp.o stm32l0xx_hal_comp_ex.o stm32l0xx_hal_cortex.o stm32l0xx_hal_crc.o stm32l0xx_hal_crc_ex.o stm32l0xx_hal_cryp.o stm32l0xx_hal_cryp_ex.o stm32l0xx_hal_dac.o stm32l0xx_hal_dac_ex.o stm32l0xx_hal_dma.o stm32l0xx_hal_firewall.o stm32l0xx_hal_flash.o stm32l0xx_hal_flash_ex.o stm32l0xx_hal_flash_ramfunc.o stm32l0xx_hal_gpio.o stm32l0xx_hal_i2c.o stm32l0xx_hal_i2c_ex.o stm32l0xx_hal_i2s.o stm32l0xx_hal_irda.o stm32l0xx_hal_iwdg.o stm32l0xx_hal_lcd.o stm32l0xx_hal_lptim.o stm32l0xx_hal_pcd.o stm32l0xx_hal_pcd_ex.o stm32l0xx_hal_pwr.o stm32l0xx_hal_pwr_ex.o stm32l0xx_hal_rcc.o stm32l0xx_hal_rcc_ex.o stm32l0xx_hal_rng.o stm32l0xx_hal_rtc.o stm32l0xx_hal_rtc_ex.o stm32l0xx_hal_smartcard.o stm32l0xx_hal_smartcard_ex.o stm32l0xx_hal_smbus.o stm32l0xx_hal_spi.o stm32l0xx_hal_tim.o stm32l0xx_hal_tim_ex.o stm32l0xx_hal_tsc.o stm32l0xx_hal_uart.o stm32l0xx_hal_uart_ex.o stm32l0xx_hal_usart.o stm32l0xx_hal_wwdg.o stm32l0xx_ll_adc.o stm32l0xx_ll_comp.o stm32l0xx_ll_crc.o stm32l0xx_ll_crs.o stm32l0xx_ll_dac.o stm32l0xx_ll_dma.o stm32l0xx_ll_exti.o stm32l0xx_ll_gpio.o stm32l0xx_ll_i2c.o stm32l0xx_ll_lptim.o stm32l0xx_ll_lpuart.o stm32l0xx_ll_pwr.o stm32l0xx_ll_rcc.o stm32l0xx_ll_rng.o stm32l0xx_ll_rtc.o stm32l0xx_ll_spi.o stm32l0xx_ll_tim.o stm32l0xx_ll_usart.o stm32l0xx_ll_utils.o stm_spi_api.o sys.o system_stm32l0xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_L073RZ/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0/TARGET_NUCLEO_L073RZ/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32l073xx.h stm32l0xx.h system_stm32l0xx.h
    mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0/: common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h
    mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/: gpio_object.h mbed_rtx.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0/TARGET_NUCLEO_L073RZ/: objects.h PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_L073RZ/TARGET_STM/TARGET_STM32L0/device/: stm32_hal_legacy.h stm32l0xx_hal.h stm32l0xx_hal_adc.h stm32l0xx_hal_adc_ex.h stm32l0xx_hal_comp.h stm32l0xx_hal_comp_ex.h stm32l0xx_hal_conf.h stm32l0xx_hal_cortex.h stm32l0xx_hal_crc.h stm32l0xx_hal_crc_ex.h stm32l0xx_hal_cryp.h stm32l0xx_hal_cryp_ex.h stm32l0xx_hal_dac.h stm32l0xx_hal_dac_ex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_firewall.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_i2s.h stm32l0xx_hal_irda.h stm32l0xx_hal_irda_ex.h stm32l0xx_hal_iwdg.h stm32l0xx_hal_lcd.h stm32l0xx_hal_lptim.h stm32l0xx_hal_lptim_ex.h stm32l0xx_hal_pcd.h stm32l0xx_hal_pcd_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_rng.h stm32l0xx_hal_rtc.h stm32l0xx_hal_rtc_ex.h stm32l0xx_hal_smartcard.h stm32l0xx_hal_smartcard_ex.h stm32l0xx_hal_smbus.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_hal_tsc.h stm32l0xx_hal_uart.h stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart.h stm32l0xx_hal_usart_ex.h stm32l0xx_hal_wwdg.h stm32l0xx_ll_adc.h stm32l0xx_ll_bus.h stm32l0xx_ll_comp.h stm32l0xx_ll_cortex.h stm32l0xx_ll_crc.h stm32l0xx_ll_crs.h stm32l0xx_ll_dac.h stm32l0xx_ll_dma.h stm32l0xx_ll_exti.h stm32l0xx_ll_gpio.h stm32l0xx_ll_i2c.h stm32l0xx_ll_iwdg.h stm32l0xx_ll_lptim.h stm32l0xx_ll_lpuart.h stm32l0xx_ll_pwr.h stm32l0xx_ll_rcc.h stm32l0xx_ll_rng.h stm32l0xx_ll_rtc.h stm32l0xx_ll_spi.h stm32l0xx_ll_system.h stm32l0xx_ll_tim.h stm32l0xx_ll_usart.h stm32l0xx_ll_utils.h stm32l0xx_ll_wwdg.h
  group radio
    radio/SX1276Lib/debug/: debug.h
    radio/SX1276Lib/enums/: enums.h
    radio/SX1276Lib/radio/: radio.cpp radio.h
    radio/SX1276Lib/sx1276/: sx1276-hal.cpp sx1276-hal.h sx1276.cpp sx1276.h
    radio/SX1276Lib/registers/: sx1276Regs-Fsk.h sx1276Regs-LoRa.h
    radio/SX1276Lib/typedefs/: typedefs.h
  group system
    system/crypto/: aes.cpp aes.h cmac.cpp cmac.h
    system/: timer.cpp timer.h utilities.cpp utilities.h
